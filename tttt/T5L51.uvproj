# Keil uVision project T5L51.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: .\obj\1.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\T5L51
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c sys.c control.c config.c uart.c TP_draw.c timer.c VCNL4000.c ORC.C STARTUP.A51
